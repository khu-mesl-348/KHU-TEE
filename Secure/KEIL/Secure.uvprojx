# Keil uVision project Secure.uvprojx, settings and files
target Secure (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: Secure +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=4 wLevel=1
  c define: DEBUG_PORT = UART0_NS
  c include: ..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\Secure
  asm define: __ARM_FEATURE_CMSE=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\secure.sct
  link misc: --import-cmse-lib-out ..\lib\nsclib.o
  group User
    ../: main.c partition_M2351.h
    ./: crypto_service.c
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../../../Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c MKROMLib_Keil.lib
